# Keil uVision project Project.uvprojx, settings and files
target GD32F10X_HD (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F103RE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD,NDEBUG
  c include: ..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Firmware\CMSIS;..\..\Firmware\GD32F10x_standard_peripheral\Include;..\USER;..\freemodbus\modbus\include;..\freemodbus\modbus\rtu;..\freemodbus\port;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../USER/: gd32f10x_it.c main.c bootloader.c systick.c
    ../../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_dma.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group freemodbus
    ../freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncfile.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../freemodbus/modbus/: mb.c
  group freemodbus/port
    ../freemodbus/port/: user_mb_app.c
    ../freemodbus/port/rtt/: port.c portevent.c portserial.c porttimer.c
  group BSP
    ../BSP/: bsp_led.c
